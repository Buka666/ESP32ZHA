## sdkconfig.defaults
```kconfig
CONFIG_ZB_ENABLED=y
CONFIG_ZB_ZED=y
CONFIG_ZB_SDK_1xx=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
```
